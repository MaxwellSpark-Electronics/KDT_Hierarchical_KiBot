File: KDT_Hierarchical_KiBot.kicad_pcb (KiCad board)
At the start: 6 copper layers, 0 parts

Commit message: change to 4 layers
Other:
- copper layers 6 -> 4
